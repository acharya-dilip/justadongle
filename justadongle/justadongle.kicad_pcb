# Repository acharya-dilip/justadongle

## KiCad design justadongle/justadongle.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C12, C13, C14, C15: 10uf; C0805
C10, C11: 15pf; CAP-TH_BD5.0-P2.00-D0.8-FD
D1, D6, D7, D8, D9, D10, D11: NSR0320MW2T1G; SOD-323_L1.8-W1.3-LS2.5-RD; Manufacturer Part NSR0320MW2T1G
R1: 100k; RES-TH_BD2.4-L6.3-P10.30-D0.6
R2: 10k; RES-TH_BD2.4-L6.3-P10.30-D0.6
R3: 4.7k; RES-TH_BD2.4-L6.3-P10.30-D0.6
U1: SL2.1A_C6798314; SOP-16_L10.0-W3.9-P1.27-LS6.0-BL; Manufacturer Part SL2.1A
U2: FSUSB42MUX; MSOP-10_L3.0-W3.0-P0.50-LS5.0-BL; Manufacturer Part FSUSB42MUX
U3: LMV7219M5X/NOPB; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; Manufacturer Part LMV7219M5X/NOPB
U4: HC-USB3.0-C26; USB-3.0-A-SMD_HC-USB3.0-C26; Manufacturer Part HC-USB3.0-C26
USB1: YTC-TC16S-128_C2927282; TYPE-C-SMD_YTC-TC16S-128; LCSC Part C2927282
USB2, USB3, USB4, USB5: USB-231-ARY; USB-A-TH_USB-231-ARY; Manufacturer Part USB-231-ARY
Y1: 12Mhz; CAP-TH_BD5.0-P2.00-D0.8-FD

Connections:
CC: D10.1 (C), D11.1 (C), R1.2, U3.3 (+IN)
DM1: U1.7 (DM1), USB2.2 (D-)
DM2: U1.5 (DM2), USB3.2 (D-)
DM3: U1.3 (DM3), USB4.2 (D-)
DM4: U1.1 (DM4), USB5.2 (D-)
DM: U1.9 (DM), U2.4 (D-)
DP: U1.10 (DP), U2.3 (D+)
DP1: U1.8 (DP1), USB2.3 (D+)
DP2: U1.6 (DP2), USB3.3 (D+)
DP3: U1.4 (DP3), USB4.3 (D+)
DP4: U1.2 (DP4), USB5.3 (D+)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C10.1, C11.1, C12.2, C13.1, C14.1, C15.2, R1.1, R3.2, U1.12 (GND), U2.5 (GND), U2.10 (OE#), U3.2 (V-), U4.4 (GND), U4.10 (GND), U4.11 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB1.EH1 (EP), USB1.EH2 (EP), USB2.4 (GND), USB2.5 (GND), USB2.6 (GND), USB3.4 (GND), USB3.5 (GND), USB3.6 (GND), USB4.4 (GND), USB4.5 (GND), USB4.6 (GND), USB5.4 (GND), USB5.5 (GND), USB5.6 (GND)
unnamed: D1.2 (A), U4.1 (VBUS)
unnamed: D6.2 (A), USB1.B4 (VBUS)
unnamed: D7.2 (A), USB1.B9 (VBUS)
unnamed: D8.2 (A), USB1.A4 (VBUS)
unnamed: D9.2 (A), USB1.A9 (VBUS)
unnamed: D10.2 (A), USB1.B5 (CC2)
unnamed: D11.2 (A), USB1.A5 (CC1)
unnamed: C6.2, U1.14 (VDD18)
unnamed: C7.2, U1.13 (VDD33)
unnamed: C10.2, U1.16 (XIN), Y1.1
unnamed: C11.2, U1.15 (XOUT), Y1.2
unnamed: U2.7 (HSD1+), U4.3 (D+)
unnamed: U2.6 (HSD1-), U4.2 (D-)
unnamed: U2.9 (HSD2+), USB1.A6 (Dp1)
unnamed: U2.8 (HSD2-), USB1.A7 (Dn1)
unnamed: R2.2, R3.1, U3.4 (-IN)
Powah: C1.2, C2.2, C3.2, C4.2, C5.2, C12.1, C13.2, C14.2, C15.1, D1.1 (C), D6.1 (C), D7.1 (C), D8.1 (C), D9.1 (C), R2.1, U1.11 (VDD5), U2.1 (VCC), U3.5 (V+), USB2.1 (VBUS), USB3.1 (VBUS), USB4.1 (VBUS), USB5.1 (VBUS)
SEL: U2.2 (Sel), U3.1 (OUT)

Board: 2 copper layers, 74.2 x 92.9 mm, 33 parts (0 on the bottom side), 30 nets.

## Commit log

2025-08-14 STUFF
2025-08-14 Completed the schamatic for the tutorial USB Port with 4 usb females and one male
2025-08-14 Figured out all the stuff except for the sel logic and havent started on the female ports other than USB-A yet
2025-08-14 Completed the USB-A and USB-C interchangeable and automatic switcheroo thingy to detetct which connector is plugged in and automatically switch to it
2025-08-14 replaced the USB 2.0 Connector with USB 3.0 for extra power
2025-08-22 Completed the Schematic moving on to the PCB Design
2025-08-22 got the correct footprints for stuff
2025-08-22 Added the footprints for all the componenets in the schematic
2025-08-26 Finished the Board
2025-08-28 gerber filez
2025-09-10 starting out
2025-09-12 corrected the usb -c symbol and wired it
2025-09-12 redesigned the whole thingy cause of the messed up c port and additional capacitors and diodes
